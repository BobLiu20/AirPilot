# Keil uVision project AirPilot.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AirPilot
  c flags: Optim=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1,__CC_ARM
  c include: .\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\User;.\BSP;.\uC-CPU;.\uC-LIB;.\uC-LIB\Cfg;.\uCOS-III;.\uCOS-III\Cfg;.\uCOS-III\Ports;.\uCOS-III\Source;.\Dir;.\Modules
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c config.h System.c
    ./uCOS-III/: includes.h
  group Modules
    ./Modules/: AP_Actuator.c AP_IMU.c AP_Altitude.c AP_Sensor.c AP_Mixer.c AP_Serial.c AP_RC.c AP_GPS.c AP_Telemetry.c AP_Daemon.c AP_OpticalFlow.c AP_EasyCtrl.c AP_VisionLanding.c AP_Avoid.c
  group Library
    ./User/: AP_PID.c
  group Dir
    ./Dir/: AP_Flash.c AP_USART.c AP_I2C.c AP_MPU6050.c AP_HMC5883.c AP_MS5611.c AP_LED.c AP_PWM.c AP_XbeePro.c AP_Sonar.c AP_SonarAvoid.c AP_Battery.c
  group FWlib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group BSP
    ./BSP/: bsp.c bsp_int.c
  group uC_CPU
    ./uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uC_LIB
    ./uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOSiii
    ./uCOS-III/Cfg/: os_app_hooks.c
    ./uCOS-III/Ports/: os_cpu_a.asm os_cpu_c.c
  group uC_Source
    ./uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
software components: CMSIS:CORE 4.3.0
